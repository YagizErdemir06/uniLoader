## configs/ruby_defconfig
```kconfig
CONFIG_SIMPLE_FB=y
CONFIG_MT6877=y
CONFIG_XIAOMI_RUBY=y
CONFIG_RAMDISK_ENTRY=0x51100000
CONFIG_PAYLOAD_ENTRY=0x50000000
CONFIG_COMPRESS_LZ4=y
```
